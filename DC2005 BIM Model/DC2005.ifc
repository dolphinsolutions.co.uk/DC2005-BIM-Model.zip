Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-11-30T16:11:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Nov 30 16:11:56 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\f6330686-a3ed-4452-bde1-e29b56bc726e\b050960e-6024-4b18-b112-4379210ce9ea\ifc * Database version: 5507 * Database creation date: Sat Nov 30 16:11:56 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Nov 30 16:11:56 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Nov 30 16:11:56 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: DC2005, DC2005:DC2005:351044
In: Level 1
Type - PredefinedType: TOILETPAN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 537 mm; Width: 371 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_94 : WC pans; CAWS: N13/300 WCs and cisterns_N13/10 WC pans and flushing arrangements; CodePerformance: BSEN997-Class 2; Color: White; Constituents: n/a; Description: DolphinWallMountedWCPanAndSeat; DurationUnit: year; ExpectedLife: n/a; Finish: White Gloss; Form: Wall-mounted, siphonic.; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: TOILETPAN; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: https://www.dolphinsolutions.co.uk/product/dolphin-wall-mounted-pan/; Material: VitreousChina; ModelNumber: DC2005; ModelReference: DolphinSolutionsLimited_WallMountedWCPanAndSeat; Name: DolphinStainlessSteel_WallMountedWCPanAndSeat_DC2005; NBSCode: 45-35-70/384 WC pans; NBSDescription: WC pans; NominalHeight: 350; NominalLength: 537; NominalWidth: 371; OmniClass Number: 23.45.05.21.11.11; OmniClass Title: Water Operated Water Closets; ReplacementCost: n/a; Size: 350x537x371; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC2005; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Title: WC pans; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC2005
Type - Visibility - Seat: yes
Type - Pset_SanitaryTerminalTypeBath - NominalLength: 163678 mm; NominalWidth: 113081 mm; Color: White
Type - Pset_SanitaryTerminalTypeBidet - NominalLength: 163678 mm; NominalWidth: 113081 mm; Color: White
Type - Pset_SanitaryTerminalTypeSanitaryFountain - NominalLength: 163678 mm; NominalWidth: 113081 mm; Color: White
Type - Pset_SanitaryTerminalTypeShower - NominalLength: 163678 mm; NominalWidth: 113081 mm; Color: White
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 163678 mm; NominalWidth: 113081 mm; Color: White
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 163678 mm; NominalWidth: 113081 mm
Type - Pset_SanitaryTerminalTypeUrinal - NominalLength: 163678 mm; NominalWidth: 113081 mm
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalLength: 163678 mm; NominalWidth: 113081 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: DC2005:DC2005; sets with these values: 2
Pset_ElementShading - Color: White
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WallMountedWCPanAndSeat; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: DolphinStainlessSteel_WallMountedWCPanAndSeat_DC2005; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.679161 m2; Volume: 0.0360526 m3
Identity Data - Mark: 1
Other - Family: DC2005: DC2005; Family and Type: DC2005: DC2005; Type: DC2005: DC2005; Type Id: DC2005: DC2005
Phasing - Phase Created: New Construction
